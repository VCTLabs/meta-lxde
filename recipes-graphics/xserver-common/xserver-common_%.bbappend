#lxsession does already start XDG autostart files
SRC_URI_remove = " \
    file://0003-add-89xdgautostart-Xsession.d-script.patch \
"

